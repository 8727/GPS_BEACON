# Keil uVision project RTOS_GPS_BEACON_v1_1.uvprojx, settings and files
target GPS_BEACON_v1_1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L151C8Tx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPS_BEACON_v1_1 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\GPS_BEACON;.\CMSIS\inc;..\SOURCE\inc;..\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32l1xx.c
  group StartUp
    ./CMSIS/StartUp/: startup_stm32l1xx_md.s
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group Source
    ../SOURCE/src/: main.c sysInit.c setting.c
